PKG:${PN}-dev = "libyaml-cpp-070-dev"
PKG:${PN}-dbg = "libyaml-cpp-070-dbg"
PKG:${PN}-src = "libyaml-cpp-070-src"
