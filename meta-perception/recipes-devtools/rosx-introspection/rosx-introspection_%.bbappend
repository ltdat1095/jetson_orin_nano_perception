FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " file://0001-Only-load-CPM-when-a-dependency-must-be-fetched.patch"
